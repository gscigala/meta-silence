do_deploy:append() {
         echo "dtoverlay=hifiberry-dac" >>${DEPLOYDIR}/bootfiles/config.txt
}