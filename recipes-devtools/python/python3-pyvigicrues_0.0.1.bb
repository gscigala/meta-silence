DESCRIPTION = "Get level and speed from many French rivers"
HOMEPAGE = "https://github.com/Mickaelh51/pyVigicrues"
SECTION = "devel/python"
#MIT, but no license file in pip package
LICENSE = "CLOSED"
LIC_FILES_CHKSUM = ""

inherit pypi setuptools3

SRC_URI[sha256sum] = "65324177ffb6bb740563e6960008a8e73ba3671458592cbde510afdec834fcc5"